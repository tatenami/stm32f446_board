# Repository tatenami/stm32f446_board

## KiCad design stm32f446.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C7, C9, C14, C15: 0.1uF; C_0603_1608Metric
C6, C10: 4.7uF; C_0805_2012Metric
C8, C11, C12: 1uF; C_0603_1608Metric
C13: 10uF; C_0805_2012Metric
C16, C17: 18pF; C_0603_1608Metric
D1, D2, D4, D5, D6, D7, D8, D9, D10: LED; LED_0603_1608Metric
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
J2: USB_B_Micro; USB_Micro-B_Amphenol_10118194-0001LF_Horizontal
J4: Conn_01x06_Pin; PinHeader_1x06_P2.54mm_Vertical
J5, J6, J7, J8: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J9, J10, J13: Conn_01x04_Socket; PinSocket_1x04_P2.54mm_Vertical
J11, J12, J14, J15, J16, J17, J18, J19, J20: Conn_01x02_Socket; PinSocket_1x02_P2.54mm_Vertical
R1, R6: 10k; R_0201_0603Metric
R2, R3: 5.1k; R_0201_0603Metric
R7, R8, R10, R11, R12, R13, R14, R15, R16: 1k; R_0201_0603Metric
SW1, SW3: SW_Push; SW_SPST_TL3305A
SW2: SW_SPDT; SPDT_akitsuki
SW4: SW_DIP_x04; SW_DIP_SPSTx04_Slide_9.78x12.34mm_W7.62mm_P2.54mm
U1: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
U2: USBLC6-2SC6; SOT-23-6
U3: MCP1703Ax-330xxDB; SOT-223-3_TabPin2
U4: CH340N; JEITA_SOIC-8_3.9x4.9mm_P1.27mm
Y1: ABM3B; Crystal_SMD_Abracon_ABM3B-4Pin_5.0x3.2mm

Connections:
+3.3V: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.1, C12.1, J4.1, J16.2, R6.1, R8.2, SW2.1 (A), U1.1 (VBAT), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U3.3 (VO)
+5V: C11.1, C13.1, C15.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J16.1, R7.2, U3.1 (VI), U4.5 (VCC)
ADC1: J20.2, U1.26 (PB0)
ADC2: J20.1, U1.27 (PB1)
BOOT0: SW2.2 (B), U1.60 (BOOT0)
BUTTON_3V3: SW3.1, SW4.1, SW4.2, SW4.3, SW4.4, U1.54 (PD2)
BUTTON_INPUT: SW3.2, U1.28 (PB2)
CAN_RX: J11.2, U1.61 (PB8)
CAN_TX: J11.1, U1.62 (PB9)
DIP1: SW4.5, U1.52 (PC11)
DIP2: SW4.6, U1.2 (PC13)
DIP3: SW4.7, U1.3 (PC14)
DIP4: SW4.8, U1.4 (PC15)
Encoder_A: J15.1, U1.59 (PB7)
Encoder_B: J15.2, U1.58 (PB6)
FreeIO1: J9.1, U1.36 (PB15)
FreeIO2: J9.2, U1.35 (PB14)
FreeIO3: J9.3, U1.34 (PB13)
FreeIO4: J9.4, U1.33 (PB12)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.2, C8.2, C9.1, C10.1, C11.2, C12.2, C13.2, C14.2, C15.1, C16.1, C17.1, D1.1 (K), D2.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.5 (GND), J2.SH (Shield), J4.3, J5.1, J5.2, J6.1, J6.2, J7.1, J7.2, J8.1, J8.2, J17.1, J17.2, J18.1, J18.2, R1.1, R2.2, R3.2, SW1.1, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), U2.2 (GND), U3.2 (GND), U4.3 (GND), Y1.2 (G), Y1.4 (G)
I2C_SCL: J14.2, U1.29 (PB10)
I2C_SDA: J14.1, U1.53 (PC12)
LED1: R10.2, U1.8 (PC0)
LED2: R11.2, U1.9 (PC1)
LED3: R12.2, U1.10 (PC2)
LED4: R13.2, U1.11 (PC3)
LED5: R16.2, U1.24 (PC4)
NRST: C9.2, J4.5, R6.2, SW1.2, U1.7 (NRST)
unnamed: D1.2 (A), R7.1
unnamed: D2.2 (A), R8.1
unnamed: D4.2 (A), R10.1
unnamed: D5.2 (A), R11.1
unnamed: D6.2 (A), R12.1
unnamed: D7.2 (A), R13.1
unnamed: D8.2 (A), R14.1
unnamed: D9.2 (A), R15.1
unnamed: D10.2 (A), R16.1
unnamed: J1.A5 (CC1), R2.1
unnamed: J1.B5 (CC2), R3.1
unnamed: J2.3 (D+), U2.1 (I/O1)
unnamed: J2.2 (D-), U2.3 (I/O2)
unnamed: R1.2, SW2.3 (C)
unnamed: C10.2, U1.30 (VCAP_1)
unnamed: C14.1, U4.8 (V3)
OSC_IN: C16.2, U1.5 (PH0), Y1.1
OSC_OUT: C17.2, U1.6 (PH1), Y1.3
PWM1: J10.1, U1.14 (PA0)
PWM2: J10.2, U1.15 (PA1)
PWM3: J10.3, U1.16 (PA2)
PWM4: J10.4, U1.17 (PA3)
PWM_LED1: R14.2, U1.39 (PC8)
PWM_LED2: R15.2, U1.40 (PC9)
SPI1_CS: J13.4, U1.20 (PA4)
SPI1_MISO: J13.2, U1.56 (PB4)
SPI1_MOSI: J13.1, U1.57 (PB5)
SPI1_SCK: J13.3, U1.21 (PA5)
SWCLK: J4.2, U1.49 (PA14)
SWDIO: J4.4, U1.46 (PA13)
SWO: J4.6, U1.55 (PB3)
TIM3_CH1: J12.2, U1.22 (PA6)
TIM3_CH2: J12.1, U1.23 (PA7)
UART3_RX: J19.2, U1.25 (PC5)
UART3_TX: J19.1, U1.51 (PC10)
UART_RX(STM): U1.38 (PC7), U4.6 (TXD)
UART_TX(STM): U1.37 (PC6), U4.7 (RXD)
USB1-DM: J1.A7 (D-), J1.B7 (D-), U4.2 (UD-)
USB1-DP: J1.A6 (D+), J1.B6 (D+), U4.1 (UD+)
USB_DM: U1.44 (PA11), U2.6 (I/O1)
USB_DP: U1.45 (PA12), U2.4 (I/O2)
USB_VBUS: J2.1 (VBUS), U1.42 (PA9), U2.5 (VBUS)

Notes on the sheet:
USB1(シリアル通信・電源)
BOOT0切り替えスイッチ
MCU-VCC
USB-VBUS
電力供給用レギュレータ

Board: 2 copper layers, 60.0 x 80.0 mm, 67 parts (4 on the bottom side), 70 nets.
